options:
  parameters:
    author: Marcus Leech, CCERA.ca
    generate_options: qt_gui
    id: deuterium
    output_language: python
    run_options: run
    title: Deuterium Spectral Logger
  states: {}

blocks:
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*fftsize)
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: lentaps
  id: variable
  parameters:
    value: len(taps)
  states: {}
- name: reduction
  id: variable
  parameters:
    value: int(integrate*(srate/10)/fftsize)
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/fftsize)
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0,srate,srate/21,srate/60)
  states: {}
- name: Logger
  id: epy_block
  parameters:
    _source_code: |
      """
      A Logger for the IDEA Deuterium project

      We accumulate average spectra in two categories
         o Main -- 97% of the samples go here
         o Baseline - 3% of the samples go here

      The idea is that because the D1 line is soooooo very weak, we can
        "baseline" just using a very small amount of the sky data itself, because
        less than 1 part in 1e6 will contain the actual line.

      We log on a daily basis, so baselining is done on a daily basis. The resulting
        baselined spectrum is logged once per day.  In post-processing a "grand"
        integration can be done over many many days, and many many stations.
        
      """

      import numpy as np
      from gnuradio import gr
      import time
      import random
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """A Logger for the IDEA Deuterium project 
             - fftsize - size of the FFT used for logging
             - outfile - prefix for the output file
             - loginterval - logging interval, hours
             """

          def __init__(self, fftsize=1024,outfile="deuterium-",loginterval=4):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Deuterium Logger',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              #
              # Output file prefix here
              #
              self.outfile = outfile
              self.loginterval = loginterval
              #
              # Create averaging buffers for both main and baseline
              #
              self.main = np.zeros(fftsize)
              self.baseline = np.zeros(fftsize)
              self.maincount = 0
              self.basecount = 0
              
              #
              # Record start time
              #
              self.startt = time.time()
              
              #
              # Seed the random number generator
              #
              random.seed()

          def work(self, input_items, output_items):
              """Log vector from FFT"""
              
              for v in input_items[0]:
      			#
      			# With P ~= 0.03, compute a baseline average
      			#
      			#
      			# Else add it to the main average
      			#
                  x = random.randint(0,30)
                  if (x == 1):
                      self.baseline = np.add(self.baseline,v)
                      self.basecount += 1
                  else:
                      self.main = np.add(self.main, v)
                      self.maincount += 1
                  #
                  # Once a day, compute averages, log
                  #
                  if ((time.time() - self.startt) >= (self.loginterval*3600)):
      				
      				#
      				# Determine filename
      				#
                      ltp = time.gmtime()
                      fn = self.outfile + "%04d%02d%02d-%02d" % (ltp.tm_year,ltp.tm_mon,ltp.tm_mday, ltp.tm_hour) + ".csv"
                      
                      #
                      # Open it
                      #
                      fp = open (fn, "w")
                      
                      #
                      # Write the TOD header
                      # Removed for now to make plotting easier
                      #
                      #fp.write ("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                      # 
                      
                      #
                      # Compute the average of the main buffer
                      #
                      avgmain = np.divide(self.main,self.maincount)
                      
                      #
                      # Compute the average of all samples on the input
                      # We'll use that to adjust the baselined version
                      #
                      avg = sum(avgmain)/len(v)
                      
                      #
                      # If there ARE baseline samples
                      if (self.basecount > 0):
                          avgbase = np.divide(self.baseline, self.basecount)
                      else:
                          avgbase = self.baseline
                          
                      #
                      # Subtract out the baseline
                      adjusted = np.subtract(avgmain, avgbase)
                      
                      #
                      # Adjust back up to average previous level
                      #
                      adjusted = np.add(adjusted, avg)
                      
                      #
                      # Reset both averaging buffers and counters
                      #
                      self.main = np.zeros(len(v))
                      self.baseline = np.zeros(len(v))
                      self.maincount = 0
                      self.basecount = 0
                      
                      #
                      # Write out the (adjusted) values
                      #
                      i = 0
                      for val in adjusted:
                          fp.write ("%10.6e" % val)
                          i += 1
                          #
                          # Don't write a trailing ","
                          #
                          if (i < len(v)):
                              fp.write(",")
                      fp.write("\n")
                      fp.close()
                      
                      #
                      # Reset our logging timer
                      #
                      self.startt = time.time()
                          
                  
              return len(input_items[0])
    fftsize: fftsize
    loginterval: loginterval
    outfile: prefix
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: '"Antenna Selector"'
    type: str
    value: '""'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fftsize*3
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: fftsize*2
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: fftsize
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: reduction
    type: float
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-fftsize:]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*fftsize:3*fftsize]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[fftsize:2*fftsize]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:fftsize]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/(reduction)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: fftsize
    long_form: 'True'
    type: cc
  states: {}
- name: device
  id: parameter
  parameters:
    label: '"Device string"'
    type: str
    value: '"rtl=0"'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '10'
    taps: taps
    type: ccf
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: '"Center Frequency (Hz)"'
    type: eng_float
    value: 327.4e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: integrate
  id: parameter
  parameters:
    label: '"Integration time(seconds)"'
    type: eng_float
    value: '30'
  states: {}
- name: loginterval
  id: parameter
  parameters:
    label: '"Log Interval (Hours)"'
    type: intx
    value: '6'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Filter down to srate/10
      Also insert DC-blocker
      to deal with residual DC offset
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      WOLA spectrometer
      implementation
  states: {}
- name: note_2
  id: note
  parameters:
    comment: Logging
  states: {}
- name: note_3
  id: note
  parameters:
    comment: Scaling to reduce the integrator output
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: antenna
    args: device
    bb_gain0: '25'
    bw0: srate*0.85
    freq0: frequency
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '25'
    sample_rate: srate
    sync: none
    type: fc32
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: '"Output files prefix"'
    type: str
    value: '"./deuterium-"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: srate/10
    color1: '"green"'
    fc: frequency
    fftsize: '2048'
    grid: 'True'
    label: Relative power(dB)
    label1: '"D1 Spectrum"'
    legend: 'False'
    name: '"Deuterium Spectrum"'
    type: complex
    width1: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: '"RF Gain (dB)"'
    type: eng_float
    value: '50'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: '"Sample Rate (SPS)"'
    type: eng_float
    value: 2.56e6
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: scaled_fft
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: integrated_fft
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: filtered_rf0
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: scaled_fft
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: integrated_fft
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: filtered_rf0
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_integrate_xx_0, '0', virtual_sink_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_xx_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0, '0', virtual_sink_3, '0']
- [fft_filter_xxx_0, '0', dc_blocker_xx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', fft_filter_xxx_0, '0']
- [virtual_source_1, '0', Logger, '0']
- [virtual_source_1_0, '0', blocks_multiply_const_xx_0, '0']
- [virtual_source_2, '0', blocks_delay_0, '0']
- [virtual_source_2, '0', blocks_delay_0_0, '0']
- [virtual_source_2, '0', blocks_delay_0_1, '0']
- [virtual_source_2, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
